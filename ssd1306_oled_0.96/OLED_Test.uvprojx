# Keil uVision project OLED_Test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ssd1306_oled_0.96
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\ssd1306_oled_0.96;.\CMSIS\inc;.\Code\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Sturtup
    ./Startup/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS/src/: core_cm3.c system_stm32f10x.c
  group Code
    ./Code/src/: main.c utils.c led.c button.c fonts.c ssd1306.c ssd1306_i2c.c
  group Application
    ./Code/inc/: main.h utils.h led.h button.h fonts.h ssd1306.h ssd1306_i2c.h
